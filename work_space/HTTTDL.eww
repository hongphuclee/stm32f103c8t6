<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\HTTTDL.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\HTTTDLL.ewp</path>
    </project>
    <batchBuild />
</workspace>
