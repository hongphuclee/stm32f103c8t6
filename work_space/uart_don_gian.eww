<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\uart_don_gian.ewp</path>
    </project>
    <batchBuild />
</workspace>
